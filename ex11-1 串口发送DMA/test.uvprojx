# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ex7-2
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: .\user\inc;.\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group user
    ./user/src/: at24c02.c delay.c flash.c iic.c key.c lcd.c led.c main.c spi.c uart.c font.c pic.c rtc.c touch.c exti.c timer.c adc.c clock.c dma.c
software components: CMSIS:CORE 4.3.0
