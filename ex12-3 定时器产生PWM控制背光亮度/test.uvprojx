# Keil uVision project test.uvprojx, settings and files
target test (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: .\CMSIS;.\user\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group USER
    ./user/src/: main.c led.c key.c uart.c exti.c delay.c iic.c at24c02.c spi.c flash.c lcd.c ascii.c adc.c dma.c time.c
software components: CMSIS:CORE 4.3.0
