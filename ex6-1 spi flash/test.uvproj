# Keil uVision project test.uvproj, settings and files
target test (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx
  c include: .\CMSIS;.\user\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ./CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group user
    ./user/src/: main.c key.c delay.c led.c uart.c iic.c at24c02.c spi.c flash.c
